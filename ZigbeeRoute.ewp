# IAR project ZigbeeRoute.ewp, settings and files
configuration 1 nut (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SWITCH_1_BUTTON; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeRoute/ZigbeeRoute_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeRoute\ZigbeeRoute_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\framework\include; ..\..\..\app\util; ..\..\..\stack; ..\..\..\hal; ..\..\..\hal\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeRoute/ZigbeeRoute_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeRoute\ZigbeeRoute_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\framework\include; ..\..\..\stack; ..\..\..\app\util; ..\..\..\hal; ..\..\..\hal\..
  OBJCOPY.OOCOutputFile: 1 nut.hex
  postbuild: ZigbeeRoute.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: 1 nut.out
  ILINK.IlinkConfigDefines: NULL_BTL=1; RAM_RETAIN_SIZE=12K
  ILINK.IlinkIcfFile: ..\..\..\hal\micro\cortexm3\em35x\em357\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
configuration 2 nut (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SWITCH_2_BUTTON; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeRoute/ZigbeeRoute_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeRoute\ZigbeeRoute_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute.h"; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: 2 nut.hex
  ILINK.IlinkOutputFile: 2 nut.out
configuration 3 nut (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SWITCH_3_BUTTON; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeRoute/ZigbeeRoute_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeRoute\ZigbeeRoute_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute.h"; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: 3 nut.hex
  ILINK.IlinkOutputFile: 3 nut.out
configuration 4 nut (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SWITCH_4_BUTTON; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeRoute/ZigbeeRoute_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeRoute\ZigbeeRoute_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute.h"; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: 4 nut.hex
  ILINK.IlinkOutputFile: 4 nut.out
configuration dim (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DIMMER; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeRoute/ZigbeeRoute_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeRoute\ZigbeeRoute_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute.h"; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: dim.hex
  ILINK.IlinkOutputFile: dim.out
configuration rem (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CURTAIN; DIMMER; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeRoute/ZigbeeRoute_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeRoute\ZigbeeRoute_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeRoute/ZigbeeRoute.h"; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: rem.hex
  ILINK.IlinkOutputFile: rem.out
  group (top)
    ../../framework/util/: af-main-soc.c config.h
    ./: ButtonExe.c call-command-handler.c ConfigDevice.h halDelay.c task.c UART_task.c Utiliti.c ZigbeeRoute.h ZigbeeRoute_callbacks.c ZigbeeRoute_endpoint_config.h ZigbeeRoute_tokens.h
    ../../framework/plugin/level-control/: level-control.c
    ../../framework/plugin/on-off/: on-off.c
  group Libraries
    ../../../build/alarm-stub-library-cortexm3-iar-em357-em3xx/: alarm-stub-library.a
    ../../../build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../build/debug-basic-library-cortexm3-iar-em357-em3xx/: debug-basic-library.a
    ../../../build/debug-extended-stub-library-cortexm3-iar-em357-em3xx/: debug-extended-stub-library.a
    ../../../build/end-device-bind-library-cortexm3-iar-em357-em3xx/: end-device-bind-library.a
    ../../../build/enhanced-beacon-request-stub-library-cortexm3-iar-em357-em3xx/: enhanced-beacon-request-stub-library.a
    ../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em357-em3xx/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em357-em3xx/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-em357-em3xx/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../build/sim-eeprom1-library-cortexm3-iar-em357-em3xx/: sim-eeprom1-library.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-em357-em3xx/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
  group System Libs
    ../../../hal/micro/cortexm3/: adc.c assert-crash-handlers.c button.c buzzer.c cstartup-iar-common.c diagnostic.c ext-device.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c spi-master.c token-def.c token.c uart.c
    ../../framework/plugin/address-table/: address-table-cli.c address-table-management.c address-table-soc.c
    ../../framework/util/: af-event.c af-main-common.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c time-util.c util.c
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ./: callback-stub.c cli.c stack-handler-stub.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../util/serial/: command-interpreter2.c ember-printf.c serial.c
    ../../framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
    ../../../hal/: ember-configuration.c
    ../../framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../framework/plugin/general-response-commands/: general-response-commands.c
    ../../framework/plugin/groups-server/: groups-server-cli.c groups-server.c
    ../../framework/plugin/identify/: identify-cli.c identify.c
    ../../framework/plugin/identify-feedback/: identify-feedback.c
    ../../framework/plugin-soc/idle-sleep/: idle-sleep-cli.c idle-sleep-soc.c idle-sleep.c
    ../../framework/plugin/network-find/: network-find.c
    ../../framework/plugin/reporting/: reporting-cli.c reporting.c
    ../../framework/plugin/scenes/: scenes-cli.c scenes.c
    ../../util/security/: security-address-cache.c
    ../../framework/plugin/simple-main/: simple-main.c
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
